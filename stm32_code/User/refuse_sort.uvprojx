# Keil uVision project refuse_sort.uvprojx, settings and files
target refuse_sort (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: refuse_sort +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Core;..\STM32F10x_FWLib\inc;..\Hardware\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group Hardware
    ../Hardware/src/: led.c usart.c motor.c delay.c
  group Readme
    ../Readme/: readme.txt
